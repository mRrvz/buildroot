## package/encrypted_proto_example/Config.in
```kconfig
config BR2_PACKAGE_ENCRYPTED_PROTO_EXAMPLE
	bool "encrypted proto example"
	help
	  Encrypted proto client and server example apps.
```
